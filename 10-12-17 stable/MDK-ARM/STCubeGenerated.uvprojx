# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STCubeGenerated
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;                                                 ..\Drivers\BSP\STM32746G-Discovery;           C:/Users/Alex/STM32Cube/Repository/STM32Cube_FW_F7_V1.8.0/Drivers/STM32F7xx_HAL_Driver/Inc;           C:/Users/Alex/STM32Cube/Repository/STM32Cube_FW_F7_V1.8.0/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;           C:/Users/Alex/STM32Cube/Repository/STM32Cube_FW_F7_V1.8.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include;           C:/Users/Alex/STM32Cube/Repository/STM32Cube_FW_F7_V1.8.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c splash.c stm32746g_discovery_ts.c ft5336.c gui.c spi.c stm32f7xx_hal_msp.c stm32f7xx_it.c main.c
  group Drivers/STM32F7xx_HAL_Driver
    C:/Users/Alex/STM32Cube/Repository/STM32Cube_FW_F7_V1.8.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sdram.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_spi.c stm32f7xx_ll_fmc.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dsi.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal.c stm32f7xx_hal_dma.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0
